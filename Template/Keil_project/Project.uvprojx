# Keil uVision project Project.uvprojx, settings and files
target GD32E23x (6220000::V6.22::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project
  AfterMake: fromelf --bin --output=.\output\@L.bin !L
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\..\Firmware\CMSIS;..\..\Utilities;..\;..\..\Utilities\LCD_Commom;..\..\Firmware\GD32E23x_standard_peripheral\Include;..\..\Firmware\CMSIS\GD\GD32E23x\Include;..\..\Source\FreeRTOS\inc;..\..\Source\FreeRTOS\src;..\..\Source\FreeRTOS\port;..\..\Source\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group App
    ../: gd32e23x_it.c main.c systick.c main.h
    ../../Source/FreeRTOS/: FreeRTOSConfig.h
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group Utilities
    ../../Utilities/: gd32e230c_eval.c
  group Doc
    ../: readme.txt
  group GD32E23x_src
    ../../Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group GD32E23x_inc
    ../../Firmware/GD32E23x_standard_peripheral/Include/: gd32e23x_adc.h gd32e23x_cmp.h gd32e23x_crc.h gd32e23x_dbg.h gd32e23x_dma.h gd32e23x_exti.h gd32e23x_fmc.h gd32e23x_fwdgt.h gd32e23x_gpio.h gd32e23x_i2c.h gd32e23x_misc.h gd32e23x_pmu.h gd32e23x_rcu.h gd32e23x_rtc.h gd32e23x_spi.h gd32e23x_syscfg.h gd32e23x_timer.h gd32e23x_usart.h gd32e23x_wwdgt.h
  group common
    ../../Source/uart/: uart.c uart.h
    ../../Source/adc/: adc.c adc.h
    ../../Source/gpio/: gpio.c gpio.h
    ../../Source/protocol/: protocol.c protocol.h
    ../../Source/flash/: flash.c flash.h
    ../../Source/eventbus/: eventbus.c eventbus.h
    ../../Source/pwm/: pwm.c pwm.h curve_table.h
    ../../Source/watchdog/: watchdog.c watchdog.h
    ../../Source/zero/: zero.c zero.h
  group device
    ../../Source/device/: jump_device.c jump_device.h device_manager.h quick_box.c quick_box.h panel_key.c panel_key.h
    ../../Source/config/: config.c config.h
  group base
    ../../Source/base/: base.h debug.h panel_base.c panel_base.h base.c
  group FreeRTOS_src
    ../../Source/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_inc
    ../../Source/FreeRTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS_port
    ../../Source/FreeRTOS/port/: port.c portasm.h portmacro.h portmacrocommon.h portasm.c
    ../../Source/FreeRTOS/port/MemMang/: heap_1.c
software components: CMSIS:CORE 6.1.0
